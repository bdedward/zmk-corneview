## boards/shields/corne_left_nice_view_p006/Kconfig
```kconfig
config SHIELD_CORNE_LEFT_NICE_VIEW_CUSTOM
    bool "Corne Left with Nice!View and CS on P0.06"
    depends on SHIELD_CORNE_LEFT
```
